File: Chessboard Eighth.kicad_sch (KiCad schematic)
At the start: 10 parts

Commit message: Oh man we're doing this again
Other:
- moved on the sheet: U20, U21, U22, U25, U26, U27
